# Keil uVision project Star.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: Star
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER,LIGHT_WS2812_UC_STM32F0XX,F_CPU=16000000
  c include: .\STM32F0xx_StdPeriph_Driver\inc;.\sources;.\ws2812;.\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./sources/: ace_pins.c ace_usart.c main.c
    ./ws2812/: ws281x.c
  group StdLib
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_usart.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_dma.c stm32f0xx_tim.c stm32f0xx_gpio.c stm32f0xx_adc.c stm32f0xx_crc.c
    ./STM32F0xx_StdPeriph_Driver/: startup_stm32f030.s
  group ::Device
    RTE/Device/STM32F030F4/: system_stm32f0xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
